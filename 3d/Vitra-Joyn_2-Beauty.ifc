Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-24T17:47:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 24 17:47:03 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\6370848e-0c6c-4ef0-8591-01e2421c9540\3daed044-8437-4334-b681-64500227e790\ifc * Database version: 5507 * Database creation date: Wed May 24 17:46:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 24 17:46:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 24 17:46:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Joyn 2 Platform - Central screen, Vitra-Joyn_2-Accesories_rfa:Joyn 2 Platform - Central screen:950756
In: Level 1
Type - Material: Nero cream white 87, Basic dark powder-coated 30
Type - Constraints - Default Elevation: 0 mm
Type - Construction - AccesoryType: Joyn_2-Accesories_Central-Screen
Type - Dimensions - NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Accesories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Design: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Central screen; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Central screen; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Accesories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Accesories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Accesories_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Central screen
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.532428 m2; Volume: 0.0524849 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; TextileMaterial: Nero cream white 87
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Central screen; Family and Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Central screen; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Central screen; Type Id: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Central screen; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Joyn 2 Platform - Electrification, solo, Vitra-Joyn_2-Accesories_rfa:Joyn 2 Platform - Electrification, solo:950783
In: Level 1
Type - Material: Basic dark powder-coated 30
Type - Constraints - Default Elevation: 0 mm
Type - Construction - AccesoryType: Joyn_2-Accesories_Electrification-Solo
Type - Dimensions - NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Accesories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Design: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Electrification, solo; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Electrification, solo; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Accesories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Accesories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Accesories_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Electrification, solo
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.0652505 m2; Volume: 0.00213247 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; TextileMaterial: Nero cream white 87
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Electrification, solo; Family and Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Electrification, solo; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Electrification, solo; Type Id: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Electrification, solo; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Joyn 2 Platform - Legs (2)
In: Level 1
Type - Material: 04 white
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 1474.01 mm; NominalHeight: 715 mm; NominalLength: 242.204 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Platform-Legs_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Designer: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Legs; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Legs; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Platform-Legs_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Platform-Legs_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 242x1472x715 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Platform-Legs_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Legs
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 1.58411 m2; Volume: 0.255263 m3
Materials and Finishes - SurfaceMaterial: 04 white
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Platform-Legs_rfa: Joyn 2 Platform - Legs; Family and Type: Vitra-Joyn_2-Platform-Legs_rfa: Joyn 2 Platform - Legs; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Platform-Legs_rfa: Joyn 2 Platform - Legs; Type Id: Vitra-Joyn_2-Platform-Legs_rfa: Joyn 2 Platform - Legs; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Joyn_2-Platform-Legs_rfa:Joyn 2 Platform - Legs:...)
950747
950750

# IfcFurnishingElement: Joyn 2 Platform - Side screen, dual, Vitra-Joyn_2-Accesories_rfa:Joyn 2 Platform - Side screen, dual:950762
In: Level 1
Type - Material: Nero cream white 87, 04 white
Type - Constraints - Default Elevation: 0 mm
Type - Construction - AccesoryType: Joyn_2-Accesories_Side-Screen-Dual
Type - Dimensions - NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Accesories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Design: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Side screen, dual; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Side screen, dual; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Accesories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Accesories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Accesories_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Side screen, dual
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.715228 m2; Volume: 0.0237707 m3
Materials and Finishes - TextileMaterial: Nero cream white 87; BaseMaterial: 04 white
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, dual; Family and Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, dual; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, dual; Type Id: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, dual; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Joyn 2 Platform - Side screen, solo, Vitra-Joyn_2-Accesories_rfa:Joyn 2 Platform - Side screen, solo:950774
In: Level 1
Type - Material: Nero cream white 87, 04 white
Type - Constraints - Default Elevation: 0 mm
Type - Construction - AccesoryType: Joyn_2-Accesories_Side-Screen-Solo
Type - Dimensions - NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Accesories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Design: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Side screen, solo; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Side screen, solo; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Accesories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Accesories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Accesories_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Side screen, solo
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.357614 m2; Volume: 0.0118854 m3
Materials and Finishes - TextileMaterial: Nero cream white 87; BaseMaterial: 04 white
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, solo; Family and Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, solo; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, solo; Type Id: Vitra-Joyn_2-Accesories_rfa: Joyn 2 Platform - Side screen, solo; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Joyn 2 Platform - Side tables 800 (2)
In: Level 1
Type - Material: 01 basic dark, Table powder coating soft light
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 1712 mm; NominalHeight: 740 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Platform-Side_Tables_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Designer: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Side tables 800; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Side tables 800; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Platform-Side_Tables_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Melanine & metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Platform-Side_Tables_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 300-800x1712x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Platform-Side_Tables_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Side tables 800
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 1.78408 m2; Volume: 0.225984 m3
Materials and Finishes - SurfaceMaterial: 01 basic dark; TableTopMaterial: Table powder coating soft light
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Platform-Side_Tables_rfa: Joyn 2 Platform - Side tables 800; Family and Type: Vitra-Joyn_2-Platform-Side_Tables_rfa: Joyn 2 Platform - Side tables 800; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Platform-Side_Tables_rfa: Joyn 2 Platform - Side tables 800; Type Id: Vitra-Joyn_2-Platform-Side_Tables_rfa: Joyn 2 Platform - Side tables 800; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Joyn_2-Platform-Side_Tables_rfa:Joyn 2 Platform - Side tables 800:...)
950631
950637

# IfcFurnishingElement: Joyn 2 Platform - Tabletop (3)
In: Level 1
Type - Material: 01 basic dark, Table powder coating soft light
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 1712 mm; NominalHeight: 740 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Platform-Tabletop_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Platform; Cost: 0; Designer: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Platform - Tabletop; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Platform - Tabletop; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-platform
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Platform-Tabletop_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Melanine & metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Platform-Tabletop_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 1200-2400x1712x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Platform-Tabletop_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Platform - Tabletop
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - CoverControl: no; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; WidthControl: 1600 mm
Dimensions - Area: 3.28568 m2; NominalLength: 1600 mm; Volume: 0.451968 m3
Materials and Finishes - CoverMaterial: 01 basic dark; SurfaceMaterial: 01 basic dark; TableTopMaterial: Table powder coating soft light
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Platform-Tabletop_rfa: Joyn 2 Platform - Tabletop; Family and Type: Vitra-Joyn_2-Platform-Tabletop_rfa: Joyn 2 Platform - Tabletop; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Platform-Tabletop_rfa: Joyn 2 Platform - Tabletop; Type Id: Vitra-Joyn_2-Platform-Tabletop_rfa: Joyn 2 Platform - Tabletop; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Joyn_2-Platform-Tabletop_rfa:Joyn 2 Platform - Tabletop:...) | GapControl = RailControl
950616 | yes
950728 | no
950729 | yes
